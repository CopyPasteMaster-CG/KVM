### uVision2 Project, (C) Keil Software
### Do not modify !

Target (KVM), 0x0000 // Tools: 'MCS-51'

Group (CPU)
Group (MAIN)
Group (UART)
Group (MSTIMER)
Group (FLASH)
Group (SPI)
Group (SPI_Flash)
Group (Project)
Group (TASK_MAN)
Group (GPIO)
Group (PS2_Host)
Group (DATA_STREAM)
Group (KVM_Console)
Group (KVM_BUTTON)
Group (KVM_EDID)
Group (USB_DC)
Group (USBDC_Virtual_HUB)
Group (USBDC_Virtual_HID)
Group (USB_HC)
Group (PowerSaving)
Group (USBHC_HUB)
Group (USBHC_MSC)
Group (USBHC_AUDIO)
Group (USBHC_HID)
Group (USBHC_HID_PARSER)
Group (USBHC_ROOT_HUB)
Group (USBDC_MSC)
Group (Special_Handler)
Group (SWDMA)
Group (ASIX_VENDOR_Handler)

File 1,1,<..\Src\cpu\cpu.c><cpu.c>
File 1,1,<..\Src\cpu\interrupt.c><interrupt.c>
File 1,2,<..\Src\cpu\START390.A51><START390.A51>
File 2,1,<..\Src\main\main.c><main.c>
File 3,1,<..\Src\uart\uart.c><uart.c>
File 4,1,<..\Src\mstimer\mstimer.c><mstimer.c>
File 5,1,<..\Src\storage\storage.c><storage.c>
File 5,1,<..\Src\flash\flash.c><flash.c>
File 6,1,<..\Src\spi\spim.c><spim.c>
File 7,1,<..\Src\kvm_control\kvm_storage\spi_flash\spi_flash.c><spi_flash.c>
File 8,5,<..\Src\project\project_include.h><project_include.h>
File 8,5,<..\Src\project\system_cfg.h><system_cfg.h>
File 9,1,<..\Src\task_man\task_main.c><task_main.c>
File 10,1,<..\Src\gpio\gpio.c><gpio.c>
File 11,1,<..\Src\ps2_host\ps2_host.c><ps2_host.c>
File 11,1,<..\Src\hardware_ps2\hardware_ps2.c><hardware_ps2.c>
File 12,1,<..\Src\data_stream\data_stream.c><data_stream.c>
File 12,1,<..\Src\data_stream\data_stream_generic.c><data_stream_generic.c>
File 13,1,<..\Src\kvm_control\kvm_console\kvm_console.c><kvm_console.c>
File 13,1,<..\Src\kvm_control\kvm_hotkey\kvm_hotkey.c><kvm_hotkey.c>
File 13,1,<..\Src\kvm_control\kvm_buzzer\buzzer_hardware.c><buzzer_hardware.c>
File 14,1,<..\Src\kvm_control\kvm_button\btn_interrupt.c><btn_interrupt.c>
File 15,1,<..\Src\kvm_control\kvm_edid\console_edid.c><console_edid.c>
File 15,1,<..\Src\kvm_control\kvm_edid\edid_hardware.c><edid_hardware.c>
File 16,1,<..\Src\usbdc\usbdc.c><usbdc.c>
File 16,1,<..\Src\usbdc\usbdc_regs.c><usbdc_regs.c>
File 16,1,<..\Src\usbdc\usbdc_hal.c><usbdc_hal.c>
File 16,1,<..\Src\usbdc\usbdc_virtual\usbdc_virtual_core.c><usbdc_virtual_core.c>
File 17,1,<..\Src\usbdc\usbdc_hub\usbdc_vhub.c><usbdc_vhub.c>
File 17,1,<..\Src\usbdc\usbdc_hub\usbdc_vhub_desc.c><usbdc_vhub_desc.c>
File 18,1,<..\Src\usbdc\usbdc_hid\usbdc_vhid.c><usbdc_vhid.c>
File 18,1,<..\Src\usbdc\usbdc_hid\usbdc_vhid_desc.c><usbdc_vhid_desc.c>
File 19,1,<..\Src\usbhc\usbhc.c><usbhc.c>
File 19,1,<..\Src\usbhc\usbhc_core.c><usbhc_core.c>
File 19,1,<..\Src\usbhc\usbhc_ioreq.c><usbhc_ioreq.c>
File 19,1,<..\Src\usbhc\usbhc_stdreq.c><usbhc_stdreq.c>
File 19,1,<..\Src\usbhc\usbhc_regs.c><usbhc_regs.c>
File 20,1,<..\Src\kvm_control\power_saving\power_saving.c><power_saving.c>
File 21,1,<..\Src\usbhc\HUB\usbhc_hub.c><usbhc_hub.c>
File 22,1,<..\Src\usbhc\MSC\usbhc_msc.c><usbhc_msc.c>
File 22,1,<..\Src\usbhc\MSC\usbhc_msc_bot.c><usbhc_msc_bot.c>
File 23,1,<..\Src\usbhc\AUDIO\usbhc_audio.c><usbhc_audio.c>
File 24,1,<..\Src\usbhc\HID\usbhc_hid.c><usbhc_hid.c>
File 25,1,<..\Src\usbhc\HID_PARSER\usbhc_hidparser.c><usbhc_hidparser.c>
File 26,1,<..\Src\usbhc\ROOT_HUB\usbhc_roothub.c><usbhc_roothub.c>
File 27,1,<..\Src\usbdc\usbdc_msc\usb_scsi\usb_scsi.c><usb_scsi.c>
File 27,1,<..\Src\usbdc\usbdc_msc\usbdc_vmsc.c><usbdc_vmsc.c>
File 27,1,<..\Src\usbdc\usbdc_msc\usbdc_vmsc_desc.c><usbdc_vmsc_desc.c>
File 28,1,<..\Src\handler\logitech\logitech.c><logitech.c>
File 28,1,<..\Src\handler\A4_Tech\a4_tech.c><a4_tech.c>
File 29,1,<..\Src\swdma\dma.c><dma.c>
File 30,1,<..\Src\usbdc\usbdc_vendor\usbdc_vendor.c><usbdc_vendor.c>


Options 1,0,0  // Target 'KVM'
 Device (AX11025)
 Vendor (ASIX Electronics Corporation)
 Cpu (IRAM(0-0xFF) CLOCK(100000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF))
 FlashUt ()
 StupF ()
 FlashDR ()
 DevID (4214)
 Rgf ()
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (DCD\)
 OrgReg (DCD\)
 TgStat=16
 OutDir (.\)
 OutName (kvm.omf)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 1 <..\makeruntime 0x0 kvm.hex kvm.bin>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 MODEL5=2
 RTOS5=0
 ROMSZ5=4
 DHOLD5=0
 XHOLD5=0
 T51FL=4833584
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,192,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 0,0,0,0,0,0,0,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,240,0,0,0,16,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=17452368
 C51VA=0
 C51MSC (STRING(FAR))
 C51DEF (RuntimeCodeAt0KH,MCU_TYPE_AX68004)
 C51UDF ()
 INCC5 (..\src\main\;..\src\cpu\;..\src\flash\;..\src\uart\;..\src\swdma\;..\src\mstimer\;..\src\i2c\;..\src\spi\;..\src\task_man\;..\src\project\;..\Src\ps2_host;..\Src\console_edid;..\Src\storage;..\Src\data_stream;..\Src\kvm_control\kvm_hotkey;..\Src\kvm_control\kvm_console;..\Src\kvm_control\kvm_button;..\Src\kvm_control\kvm_edid;..\Src\kvm_control\kvm_buzzer;..\src\gpio\;..\Src\hardware_ps2;..\Src\usbdc;..\Src\usbdc\usbdc_virtual;..\Src\usb_std;..\Src\usbhc;..\Src\kvm_control\power_saving;..\Src\usbhc\MSC;..\Src\usbhc\AUDIO;..\Src\usbhc\HUB;..\Src\usbhc\HID;..\Src\usbhc\HID_PARSER;..\Src\usbhc\ROOT_HUB;..\Src\usbdc\usbdc_hub;..\Src\usbdc\usbdc_hid;..\Src\kvm_control\kvm_storage\spi_flash;..\Src\usbdc\usbdc_msc\usb_scsi;..\Src\usbdc\usbdc_msc;..\Src\handler\logitech;..\Src\handler\A4_Tech;..\Src\usbdc\usbdc_vendor)
 AX51FL=4
 AX51MSC ()
 AX51SET (RuntimeCodeAt0KH)
 AX51RST ()
 INCA5 (..\src\main\;..\src\cpu\;..\src\flash\;..\src\uart\;..\src\swdma\;..\src\mstimer\;..\src\i2c\;..\src\spi\;)
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC (NOOVERLAY)
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)(-c390)(DP51.DLL)(-p)(S8051.DLL)(-c390)(TP51.DLL)(-p)
  OPTDBG 48125,10,()()()()()()()()()() (BIN\DCD_DoCD_USB.DLL)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,6,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\DCD_DoCD_USB.DLL)
 FLASH3 ()
 FLASH4 ()
EndOpt

