# Keil uVision project kvm.uvproj, settings and files
target kvm(68002) (MCS-51)
  device: AX11025 ASIX Electronics Corporation
  cpu: IRAM(0-0xFF) CLOCK(100000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: kvm.omf +hex
  AfterMake: ..\makeruntime 0x0 kvm.hex kvm(2_D).bin
  c flags: Optimize=9
  c define: RuntimeCodeAt0KH,MCU_TYPE_AX68002,KVM,HC_TIMEOUT=10000,VHID,HID_PARSER_CORE_KB,API,I2C_BUS,NO_AUDIO,NO_MSC
  c misc: STRING(FAR)
  c include: ..\src\main\;..\src\cpu\;..\src\flash\;..\src\uart\;..\src\swdma\;..\src\mstimer\;..\src\i2c\;..\src\spi\;..\src\task_man\;..\src\project\;..\Src\ps2_host;..\Src\console_edid;..\Src\storage;..\Src\data_stream;..\Src\kvm_control\kvm_hotkey;..\Src\kvm_control\kvm_console;..\Src\kvm_control\kvm_button;..\Src\kvm_control\kvm_edid;..\Src\kvm_control\kvm_buzzer;..\src\gpio\;..\Src\hardware_ps2;..\Src\usbdc;..\Src\usbdc\usbdc_virtual;..\Src\usb_std;..\Src\usbhc;..\Src\kvm_control\power_saving;..\Src\usbhc\MSC;..\Src\usbhc\AUDIO;..\Src\usbhc\HUB;..\Src\usbhc\HID;..\Src\usbhc\HID_PARSER;..\Src\usbhc\ROOT_HUB;..\Src\usbdc\usbdc_hub;..\Src\usbdc\usbdc_hid;..\Src\kvm_control\kvm_storage\spi_flash;..\Src\usbdc\usbdc_msc\usb_scsi;..\Src\usbdc\usbdc_msc;..\Src\handler\logitech;..\Src\handler\A4_Tech;..\Src\usbdc\usbdc_vendor;..\Src\hsur;..\Src\extender\core;..\Src\extender\receiver;..\Src\uart_console;..\Src\kvm_control\km_sync;..\Src\hsur;..\Src\kvm_control\km_log;..\Src\kvm_control\km_api;..\Src\i2c;..\Src\kvm_control\kvm_rtc;..\Src\kvm_control\kvm_ir
  asm define: RuntimeCodeAt0KH
  asm include: ..\src\main\;..\src\cpu\;..\src\flash\;..\src\uart\;..\src\swdma\;..\src\mstimer\;..\src\i2c\;..\src\spi\;
  link misc: NOOVERLAY
  group CPU
    ../Src/cpu/: cpu.c interrupt.c START390.A51
  group MAIN
    ../Src/main/: main.c
  group UART
    ../Src/uart/: uart.c
  group MSTIMER
    ../Src/mstimer/: mstimer.c
  group FLASH
    ../Src/storage/: storage.c
    ../Src/flash/: flash.c
  group SPI
    ../Src/spi/: spim.c
  group SPI_Flash
    ../Src/kvm_control/kvm_storage/spi_flash/: spi_flash.c
  group Project
    ../Src/project/: project_include.h system_cfg.h
  group TASK_MAN
    ../Src/task_man/: task_main.c
  group GPIO
    ../Src/gpio/: gpio.c
  group PS2_Host
    ../Src/ps2_host/: ps2_host.c
    ../Src/hardware_ps2/: hardware_ps2.c
  group DATA_STREAM
    ../Src/data_stream/: data_stream.c data_stream_generic.c
  group KVM_Console
    ../Src/kvm_control/kvm_console/: kvm_console.c
    ../Src/kvm_control/kvm_hotkey/: kvm_hotkey.c
    ../Src/kvm_control/kvm_buzzer/: buzzer_hardware.c
  group KVM_BUTTON
    ../Src/kvm_control/kvm_button/: btn_interrupt.c btn_polling.c
  group KVM_EDID
    ../Src/kvm_control/kvm_edid/: console_edid.c edid_hardware.c consoleS_edid.c
  group USB_DC
    ../Src/usbdc/: usbdc.c usbdc_regs.c usbdc_hal.c
    ../Src/usbdc/usbdc_virtual/: usbdc_virtual_core.c
  group USBDC_Virtual_HUB
    ../Src/usbdc/usbdc_hub/: usbdc_vhub.c usbdc_vhub_desc.c
  group USBDC_Virtual_HID
    ../Src/usbdc/usbdc_hid/: usbdc_vhid.c usbdc_vhid_desc.c
  group USB_HC
    ../Src/usbhc/: usbhc.c usbhc_core.c usbhc_ioreq.c usbhc_stdreq.c usbhc_regs.c
  group PowerSaving
    ../Src/kvm_control/power_saving/: power_saving.c
  group USBHC_HUB
    ../Src/usbhc/HUB/: usbhc_hub.c
  group USBHC_MSC
    ../Src/usbhc/MSC/: usbhc_msc_burst.c usbhc_msc_bot_burst.c
  group USBHC_AUDIO
    ../Src/usbhc/AUDIO/: usbhc_audio.c
  group USBHC_HID
    ../Src/usbhc/HID/: usbhc_hid.c
  group USBHC_HID_PARSER
    ./: km_v2_1_3_1.LIB
  group USBHC_ROOT_HUB
    ../Src/usbhc/ROOT_HUB/: usbhc_roothub.c
  group USBDC_MSC
    ../Src/usbdc/usbdc_msc/usb_scsi/: usb_scsi.c
    ../Src/usbdc/usbdc_msc/: usbdc_vmsc.c usbdc_vmsc_desc.c
  group Special_Handler
    ../Src/handler/logitech/: logitech.c
    ../Src/handler/A4_Tech/: a4_tech.c
  group SWDMA
    ../Src/swdma/: dma.c
  group ASIX_VENDOR_Handler
    ../Src/usbdc/usbdc_vendor/: usbdc_vendor.c
  group Uart_Console
    ../Src/uart_console/: uartx_console.c hsuart_driver.c
  group KM_Sync
    ../Src/kvm_control/km_sync/: km_sync.c
  group DaisyChain
    ../Src/hsur/: hsuart2.c
  group KM_Log
    ../Src/kvm_control/km_log/: km_log.c
  group KM_API
    ../Src/kvm_control/km_api/: km_api.c
  group I2C
    ../Src/i2c/: i2c_core.c
  group RTC
    ../Src/kvm_control/kvm_rtc/: kvm_rtc.c
  group IR
    ../Src/kvm_control/kvm_ir/: kvm_ir.c
  group Multiview
    ../Src/kvm_control/kvm_multiview/: kvm_multiview.c
target kvm(68004) (MCS-51)
  device: AX11025 ASIX Electronics Corporation
  cpu: as above
  output: kvm.omf +hex
  AfterMake: ..\makeruntime 0x0 kvm.hex kvm(4_D).bin
  c flags: Optimize=9
  c define: RuntimeCodeAt0KH,MCU_TYPE_AX68004,KVM,HC_TIMEOUT=10000,VHID,HID_PARSER_CORE_KB,HID_PARSER_CORE_MS,API,NO_AUDIO,NO_MSC,NO_EDID,HUART_BAUD=HUART_115K,SYNC,CROSS_JUMP_MAP0,VPID_CHANGER,SYNC_KB_HOTKEY,SYNC_MS_HOTKEY,REPEAT_MODE=1,HSUART,MULTIVIEW
  c misc: STRING(FAR)
  c include: ..\src\main\;..\src\cpu\;..\src\flash\;..\src\uart\;..\src\swdma\;..\src\mstimer\;..\src\i2c\;..\src\spi\;..\src\task_man\;..\src\project\;..\Src\ps2_host;..\Src\console_edid;..\Src\storage;..\Src\data_stream;..\Src\kvm_control\kvm_hotkey;..\Src\kvm_control\kvm_console;..\Src\kvm_control\kvm_button;..\Src\kvm_control\kvm_edid;..\Src\kvm_control\kvm_buzzer;..\src\gpio\;..\Src\hardware_ps2;..\Src\usbdc;..\Src\usbdc\usbdc_virtual;..\Src\usb_std;..\Src\usbhc;..\Src\kvm_control\power_saving;..\Src\usbhc\MSC;..\Src\usbhc\AUDIO;..\Src\usbhc\HUB;..\Src\usbhc\HID;..\Src\usbhc\HID_PARSER;..\Src\usbhc\ROOT_HUB;..\Src\usbdc\usbdc_hub;..\Src\usbdc\usbdc_hid;..\Src\kvm_control\kvm_storage\spi_flash;..\Src\usbdc\usbdc_msc\usb_scsi;..\Src\usbdc\usbdc_msc;..\Src\handler\logitech;..\Src\handler\A4_Tech;..\Src\usbdc\usbdc_vendor;..\Src\hsur;..\Src\extender\core;..\Src\extender\receiver;..\Src\uart_console;..\Src\kvm_control\km_sync;..\Src\hsur;..\Src\kvm_control\km_log;..\Src\kvm_control\km_api;..\Src\kvm_control\kvm_ir;..\Src\kvm_control\kvm_rtc;..\Src\i2c;..\Src\kvm_control\kvm_multiview
  asm define: RuntimeCodeAt0KH
  asm include: as above
  link misc: NOOVERLAY
